// SPDX-License-Identifier: BSD-3-Clause
/* Xiaomi 13 (fuxi)：disp 变体（内容见 sm8550-xiaomi-fuxi-disp.dtsi） */

#include "sm8550-xiaomi-fuxi-min.dts"
#include "sm8550-xiaomi-fuxi-disp.dtsi"
